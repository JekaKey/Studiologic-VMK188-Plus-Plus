# Keil uVision project Fatarminator.uvproj, settings and files
target Fatarminator (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Fatarminator
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: .\CMSIS;.\CMSIS\Device\ST\STM32F4xx\Include;.\Main;.\STM32F4xx_SPL\inc;.\STM32F4xx_SPL\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
  group CMSIS
    ./CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./CMSIS/: stm32f4xx_conf.h
    ./CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
  group SPL
    ./STM32F4xx_SPL/src/: stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_sdio.c stm32f4xx_rcc.c stm32f4xx_gpio.c misc.c
  group Main
    ./Main/: main.c fifo.h midi.c
